<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\KURSACH_MAXIM_F100.ewp</path>
  </project>
  <batchBuild />
</workspace>
